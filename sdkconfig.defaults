## sdkconfig.defaults
```kconfig
CONFIG_FREERTOS_HZ=1000
# CONFIG_ESP_INT_WDT is not set
# CONFIG_ESP_TASK_WDT is not set
```
